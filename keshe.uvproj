# Keil uVision project keshe.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: keshe +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\+
  group Source Group 1
    ./: main.c dht11.c screen.c
